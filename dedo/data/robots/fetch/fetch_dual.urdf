Commit message: Tuning fetch 2 angles so that it holds the apron

File: dedo/data/robots/fetch/fetch_dual.urdf (robot description, URDF)
Before this commit: robot fetch, 53 links, 52 joints
Joints:
- joint robot_l_to_world: origin xyz=0.9 0 0 rpy=0 0 3.141 -> xyz=1.75 0 0 rpy=0 0 3.141
